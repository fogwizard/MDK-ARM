# Keil uVision project dp_transmitter.uvprojx, settings and files
target app_nosbl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RC STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dp_transmitter +hex
  BeforeMake: ..\tools\genrev.bat
  BeforeMake: ..\tools\format.bat ..\tools\file_list.txt
  AfterMake: fromelf.exe ".\OBJ\dp_transmitter.axf" --bin --output "..\dp_transmitter.bin"
  AfterMake: ..\tools\qfix.exe -crc32  -f4  ..\dp_transmitter.bin OBJ\dp_transmitter.axf  ..\platform\include\board_config.h
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c misc: -I ../platform/include --C99  -I ../platform/lib/lzo -I ../platform/driver/video
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\Libraries\STM32F4xx_HAL_Driver\Inc\Legacy;..\USER;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\Libraries\STM32F4xx_HAL_Driver\Src;..\fatfs;..\driver\SDcard;..\driver\spi;..\usb_device\Inc;..\usb_device\Middlewares\STM32_USB_Device_Library\Core\Inc;..\usb_device\Middlewares\STM32_USB_Device_Library\Class\CDC\Inc;..\driver\flash;..\fatfs\option;..\driver\MALLOC;..\fatfs\exfuns;..\usb_device\Middlewares\STM32_USB_Device_Library\Class\HID\Inc;..\usb_device\Middlewares\STM32_USB_Device_Library\Class\CustomHID\Inc;..\usb_device\Middlewares\STM32_USB_Device_Library\Class\CustomHID\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xc.s
  group FATFS
    ../fatfs/: diskio.c ff.c
    ../fatfs/option/: ccsbcs.c
    ../fatfs/exfuns/: exfuns.c
  group NETWORK
    ../platform/network/: ymodem.c Modbus.c kermit.c
  group USB_FS_DEVICE
    ../usb_device/Middlewares/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../usb_device/Middlewares/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../usb_device/Middlewares/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
    ../usb_device/Middlewares/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group USB_USER
    ../usb_device/Src/: usbd_conf.c usbd_cdc_if.c usb_device.c usbd_desc.c usbd_custom_hid_if.c
  group USER
    ../platform/USER/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group KERNEL
    ../platform/kernel/: 24cxx.c adc.c base64.c Calibration.c code_verify.c devicetree.c dewpoint.c event.c Filter.c init.c InterruptISR.c log_data.c main.c rsa.c RTC_Time.c scaling.c sd_file.c timer.c alarm.c test_case.c
    ../platform/kernel/sched_clock/: sched_clock.c
    ../platform/mm/: MemoryManage.c
    ../platform/kernel/menu/: menu.c menu_sub1.c menu_sub2.c menu_sub3.c menu_sub4.c menu_sub5.c menu_sub6.c menu_sub7.c menu_sub8.c menu_sub9.c menu_sub10.c menu_sub11.c
  group DRIVER
    ../platform/driver/MALLOC/: malloc.c
    ../platform/driver/SDcard/: sdcard.c
    ../platform/driver/spi/: spi.c
    ../platform/driver/uart/: uart.c
    ../platform/driver/LCD/: lcd.c ST7565.c
    ../platform/driver/base/: bus.c dd.c driver.c platform.c
    ../platform/driver/flash/: flash.c
    ../platform/lib/lzo/: minilzo.c
    ../platform/driver/video/: GUI.c
    ../platform/fash/: IICeeprom.c
    ../platform/input/: KeyPad.c
    ../platform/lib/stdlib/: mystdio.c stdlib.c string.c
    ../platform/driver/input/: ads1232.c
  group DRIVER_DAC
    ../platform/dac/: dac8562.c dac_common.c
    ../platform/kernel/: dac8551.c
target app_sbl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RC STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: dp_transmitter +hex
  BeforeMake: ..\tools\genrev.bat
  BeforeMake: ..\tools\format.bat ..\tools\file_list.txt
  AfterMake: as above
  AfterMake: ..\tools\post.bat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,APP_WITH_SBL
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x10000
